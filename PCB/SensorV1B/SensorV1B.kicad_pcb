# Repository ilkercakir/IOBoardV1

## KiCad design PCB/SensorV1B/SensorV1B.kicad_pcb

Parts:
C1: 1uF
CON2: USB-MICRO-B
D1: LED
J1: RJ45_IN
J2: RJ45_OUT
J3, J4, J5, J6, J7, J8, J9, J10: RJ45_2
R1: 10K
U1: 74LS165

Connections:
/S1: J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, U1.11 (P0)
/S2: J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, U1.12 (P1)
/S3: J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, J10.3, U1.13 (P2)
/S4: J3.4, J4.4, J5.4, J6.4, J7.4, J8.4, J9.4, J10.4, U1.14 (P3)
/S5: J3.5, J4.5, J5.5, J6.5, J7.5, J8.5, J9.5, J10.5, U1.3 (P4)
/S6: J3.6, J4.6, J5.6, J6.6, J7.6, J8.6, J9.6, J10.6, U1.4 (P5)
/S7: J3.7, J4.7, J5.7, J6.7, J7.7, J8.7, J9.7, J10.7, U1.5 (P6)
/S8: J3.8, J4.8, J5.8, J6.8, J7.8, J8.8, J9.8, J10.8, U1.6 (P7)
GND: C1.2, CON2.5 (GND), D1.2 (K), J1.8, J2.8, U1.8 (GND), U1.15 (CE)
unnamed: J1.7, U1.9 (Q7)
unnamed: J1.2, J2.2
unnamed: J1.6, J2.6
unnamed: J1.5, J2.5
unnamed: J2.7, U1.10 (Ds)
unnamed: J1.1, J2.1
unnamed: J1.4, J2.4, U1.2 (CP)
unnamed: J1.3, J2.3, U1.1 (Pl)
unnamed: D1.1 (A), R1.2
VCC: C1.1, CON2.1 (VBUS), R1.1, U1.16 (VCC)

Board: 2 copper layers, 31.5 x 98.6 mm, 15 parts (0 on the bottom side), 19 nets.

## KiCad design PCB/WaterLevelV1/WaterLevel.kicad_pcb

Parts:
J1: RJ45_2; RJ45_8_io0
J2, J3, J4, J5, J6, J7, J8: Conn_01x02; 2PAD

Connections:
GND: J1.1, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2
unnamed: J1.2, J2.1
unnamed: J1.3, J3.1
unnamed: J1.4, J4.1
unnamed: J1.5, J5.1
unnamed: J1.6, J6.1
unnamed: J1.7, J7.1
unnamed: J1.8, J8.1

Board: 2 copper layers, 19.9 x 120.8 mm, 8 parts (0 on the bottom side), 8 nets.

## KiCad design PCB/USBPowerV1/USBPowerV1.kicad_pcb

Parts:
CON1: BARREL_JACK
CON2: USB-MICRO-B
D1: LED
P1: KLEMENS_1
P2, P3, P4, P5: CONN_12
P6: GND
R1: 10K

Connections:
GND: CON1.2, CON2.5 (GND), P1.2 (PM), P2.1, P2.5, P2.9, P2.10, P2.11, P2.12, P3.1, P3.5, P3.9, P3.10, P3.11, P3.12, P4.1, P4.5, P4.9, P4.10, P4.11, P4.12, P5.1, P5.5, P5.9, P5.10, P5.11, P5.12, P6.1, P6.2 (PM), R1.2
unnamed: D1.2 (K), R1.1
VCC: CON1.1, CON2.1 (VBUS), D1.1 (A), P1.1, P2.4, P2.8, P3.4, P3.8, P4.4, P4.8, P5.4, P5.8

Board: 2 copper layers, 17.8 x 90.3 mm, 10 parts (0 on the bottom side), 3 nets.

## KiCad design PCB/USBPowerV1C/USBPowerV1C.kicad_pcb

Parts:
CON1: BARREL_JACK
CON2: USB-MICRO-B
D1: LED
J1, J2, J3, J4, J5, J6, J7, J8: RJ45_2
P1: KLEMENS_1
P6: GND
R1: 10K

Connections:
GND: CON1.2, CON2.5 (GND), J1.2, J1.4, J1.6, J1.8, J2.2, J2.4, J2.6, J2.8, J3.2, J3.4, J3.6, J3.8, J4.2, J4.4, J4.6, J4.8, J5.2, J5.4, J5.6, J5.8, J6.2, J6.4, J6.6, J6.8, J7.2, J7.4, J7.6, J7.8, J8.2, J8.4, J8.6, J8.8, P1.2 (PM), P6.1, P6.2 (PM), R1.2
unnamed: D1.2 (K), R1.1
VCC: CON1.1, CON2.1 (VBUS), D1.1 (A), J1.1, J1.3, J1.5, J1.7, J2.1, J2.3, J2.5, J2.7, J3.1, J3.3, J3.5, J3.7, J4.1, J4.3, J4.5, J4.7, J5.1, J5.3, J5.5, J5.7, J6.1, J6.3, J6.5, J6.7, J7.1, J7.3, J7.5, J7.7, J8.1, J8.3, J8.5, J8.7, P1.1

Board: 2 copper layers, 32.0 x 83.9 mm, 14 parts (0 on the bottom side), 3 nets.

## KiCad design PCB/ControllerV1A/IOBoardV1.kicad_pcb

Parts:
C1: 330nF
C2: 1uF
D1, D2: LED
J1: RJ45_2
P1: RASPBERRY_HAT
P2: CONN_2
R1, R2, R3, R6: 10K
R4: 2.2K
R5: 3.3K
U1: 74LS138
U2: 74HC14
U3: 74LS74

Connections:
+5V: C2.1, D2.1 (A), P1.2, R1.1, R2.1, U1.16 (VCC), U2.14 (VCC), U3.1 (Cd), U3.13 (Cd), U3.14 (VCC)
GND: C1.2, C2.2, J1.8, P1.6, R3.1, R5.2, R6.2, U1.4 (E1), U1.5 (E2), U1.8 (GND), U2.7 (GND), U3.7 (GND)
unnamed: D1.2 (K), R3.2
unnamed: D1.1 (A), U3.6 (~Q)
unnamed: U1.10 (O5), U3.3 (Cp)
unnamed: U1.11 (O4), U3.11 (Cp)
unnamed: J1.1, U1.15 (O0)
unnamed: J1.3, U1.13 (O2)
unnamed: P1.18, R4.1, R5.1
unnamed: J1.7, R4.2
unnamed: P1.16, U2.3
unnamed: U1.6 (E3), U2.2
unnamed: C1.1, R2.2, U2.9
unnamed: P1.15, R1.2, U2.1
unnamed: J1.4, U1.12 (O3)
unnamed: J1.2, U2.10
unnamed: U1.14 (O1), U2.11
unnamed: J1.5, U2.4, U3.2 (D), U3.12 (D)
unnamed: U2.5, U2.8
unnamed: P2.1, U1.9 (O6)
unnamed: D2.2 (K), R6.1
unnamed: P2.2 (PM), U1.7 (O7)
unnamed: J1.6, U3.9 (Q)
unnamed: U2.6, U3.4 (Sd), U3.10 (Sd)
unnamed: P1.12, U1.2 (A1)
unnamed: P1.13, U1.3 (A2)
unnamed: P1.11, U1.1 (A0)

Board: 2 copper layers, 22.0 x 52.5 mm, 16 parts (0 on the bottom side), 27 nets.

## KiCad design PCB/ActuatorV1A/ActuatorV1A.kicad_pcb

Parts:
C1: 1uF
CON1: USB-MINI-B
D1: LED
J1: RJ45_IN
J2: RJ45_OUT
P1, P2, P3, P4, P5, P6, P7, P8: CONN_5X2
R1: 10K
U1: 74HC595

Connections:
/A1: P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, U1.15 (QA)
/A2: P1.2, P2.2, P3.2, P4.2, P5.2, P6.2, P7.2, P8.2, U1.1 (QB)
/A3: P1.3, P2.3, P3.3, P4.3, P5.3, P6.3, P7.3, P8.3, U1.2 (QC)
/A4: P1.4, P2.4, P3.4, P4.4, P5.4, P6.4, P7.4, P8.4, U1.3 (QD)
/A5: P1.5, P2.5, P3.5, P4.5, P5.5, P6.5, P7.5, P8.5, U1.4 (QE)
/A6: P1.6, P2.6, P3.6, P4.6, P5.6, P6.6, P7.6, P8.6, U1.5 (QF)
/A7: P1.7, P2.7, P3.7, P4.7, P5.7, P6.7, P7.7, P8.7, U1.6 (QG)
/A8: P1.8, P2.8, P3.8, P4.8, P5.8, P6.8, P7.8, P8.8, U1.7 (QH)
GND: C1.2, CON1.5 (GND), D1.2 (K), J1.8, J2.8, P1.10, P2.10, P3.10, P4.10, P5.10, P6.10, P7.10, P8.10, U1.8 (GND)
unnamed: J1.7, J2.7
unnamed: J1.4, J2.4
unnamed: J1.3, J2.3
unnamed: D1.1 (A), R1.2
unnamed: J2.5, U1.9 (~QH)
unnamed: J1.1, J2.1, U1.11 (SRCLK)
unnamed: J1.5, U1.14 (SER)
unnamed: J1.2, J2.2, U1.12 (RCLK)
unnamed: J1.6, J2.6, U1.13 (G)
VCC: C1.1, CON1.1 (VBUS), P1.9, P2.9, P3.9, P4.9, P5.9, P6.9, P7.9, P8.9, R1.1, U1.10 (SRCLR), U1.16 (VCC)

Board: 2 copper layers, 15.6 x 163.3 mm, 15 parts (0 on the bottom side), 19 nets.

## KiCad design PCB/RelayBoardV1B/RelayBoardV1B.kicad_pcb

Board: 2 copper layers, 54.2 x 143.1 mm, 188 parts (28 on the bottom side), 134 nets.

Parts:
C1, C3, C5, C7, C9, C11, C13, C15: 100nF; SM0805
C2, C4, C6, C8, C10, C12, C14, C16: 1uF; SM0805
CON1, CON2: USB-MICRO-B; USB_MICRO_B
D1, D2, D3, D7, D11, D15, D19, D23, D27, D31: LED; SM0805
D4, D8, D12, D16, D20, D24, D28, D32: 1N4007; DO-214AC(SMA)
D5, D6, D9, D10, D13, D14, D17, D18, D21, D22, D25, D26, D29, D30, D33, D34: 1N4148; DO-35
J1: RJ45_IN; RJ45_8_io0
J2: RJ45_OUT; RJ45_8_io0
K1, K2, K3, K4, K5, K6, K7, K8: RELAY_14F2L
P1, P2, P3, P4, P5, P6, P7, P8: KLEMENS_1; KLEMENS_3
Q1, Q4, Q7, Q10, Q13, Q16, Q19, Q22: BC856; SOT23
Q2, Q5, Q8, Q11, Q14, Q17, Q20, Q23: MMBT2222A; SOT23
Q3, Q6, Q9, Q12, Q15, Q18, Q21, Q24: 2N7002; SOT23
R1, R3, R8, R9, R10, R13, R18, R19, R20, R23, R28, R29, R30, R33, R38, R39, R40, R43, R48, R49, R50, R53, R58, R59, R60, R63, R68, R69, R70, R73, R78, R79, R80: 10K; SM0805
R2, R4, R7, R14, R17, R24, R27, R34, R37, R44, R47, R54, R57, R64, R67, R74, R77: 22K; SM0805
R5, R15, R25, R35, R45, R55, R65, R75: 2.2K; SM0805
R6, R16, R26, R36, R46, R56, R66, R76: 680R; SM0805
R11, R21, R31, R41, R51, R61, R71, R81: 100K; SM0805
R12, R22, R32, R42, R52, R62, R72, R82: 47R; SM0805
T1, T2, T3, T4, T5, T6, T7, T8: TRANSFO; EE16
U1: 74HC595; SO16N
U2: 74LS165; SO16N
U3, U4: LM324; SO14N

Connections:
+5V: C2.2, C4.2, C6.2, C8.2, C10.2, C12.2, C14.2, C16.2, CON1.1, Q1.2, Q4.2, Q7.2, Q10.2, Q13.2, Q16.2, Q19.2, Q22.2, R1.1, R3.1, R8.1, R11.2, R13.1, R18.1, R21.2, R23.1, R28.1, R31.2, R33.1, R38.1, R41.2, R43.1, R48.1, R51.2, R53.1, R58.1, R61.2, R63.1, R68.1, R71.2, R73.1, R78.1, R81.2, U1.10, U1.16, U2.16, U3.4, U4.4
+12V: CON2.1, D4.2, D8.2, D12.2, D16.2, D20.2, D24.2, D28.2, D32.2, K1.1, K2.1, K3.1, K4.1, K5.1, K6.1, K7.1, K8.1, R2.2, R7.1, R17.1, R27.1, R37.1, R47.1, R57.1, R67.1, R77.1
/Din: J1.7, U2.9
/Dout: J1.5, U1.14
/EN: J1.2, J2.2, U1.12
/OE: J1.6, J2.6, U1.13
/PL: J1.3, J2.3, U2.1
/RD: J1.4, J2.4, U2.2
/WR: J1.1, J2.1, U1.11
GND: C1.2, C3.2, C5.2, C7.2, C9.2, C11.2, C13.2, C15.2, CON1.5, CON2.5, D1.2, D2.2, J1.8, J2.8, Q2.2, Q3.2, Q5.2, Q6.2, Q8.2, Q9.2, Q11.2, Q12.2, Q14.2, Q15.2, Q17.2, Q18.2, Q20.2, Q21.2, Q23.2, Q24.2, R6.2, R9.2, R16.2, R19.2, R26.2, R29.2, R36.2, R39.2, R46.2, R49.2, R56.2, R59.2, R66.2, R69.2, R76.2, R79.2, U1.8, U2.8, U2.15, U3.11, U4.11
unnamed: R44.2, U1.4
unnamed: K5.9, K5.14, T5.2
unnamed: P5.2, T5.1
unnamed: K5.11, K5.12, P5.1
unnamed: D23.1, R57.2
unnamed: Q16.3, R55.1
unnamed: R60.1, T6.4
unnamed: P6.2, T6.1
unnamed: Q13.1, R43.2, R44.1
unnamed: C10.1, R51.1, R52.2, U2.3
unnamed: Q15.3, R52.1
unnamed: Q15.1, U4.1
unnamed: D19.2, D20.1, K5.22, Q14.3
unnamed: Q16.1, R53.2, R54.1
unnamed: Q17.1, R55.2, R56.1
unnamed: Q18.3, R62.1
unnamed: Q18.1, U4.7
unnamed: C11.1, D25.2, D26.1, R58.2, R59.1, T6.3, U4.5
unnamed: D25.1, D26.2, R60.2, U4.6
unnamed: K4.11, K4.12, P4.1
unnamed: Q12.3, R42.1
unnamed: R34.2, U1.3
unnamed: K4.9, K4.14, T4.2
unnamed: P4.2, T4.1
unnamed: Q12.1, U3.14
unnamed: R40.1, T4.4
unnamed: Q11.1, R35.2, R36.1
unnamed: Q10.1, R33.2, R34.1
unnamed: D15.2, D16.1, K4.22, Q11.3
unnamed: C8.1, R41.1, R42.2, U2.14
unnamed: D19.1, R47.2
unnamed: Q14.1, R45.2, R46.1
unnamed: Q13.3, R45.1
unnamed: C9.1, D21.2, D22.1, R48.2, R49.1, T5.3, U4.3
unnamed: R50.1, T5.4
unnamed: D21.1, D22.2, R50.2, U4.2
unnamed: C15.1, D33.2, D34.1, R78.2, R79.1, T8.3, U4.12
unnamed: C16.1, R81.1, R82.2, U2.6
unnamed: D31.1, R77.2
unnamed: Q23.1, R75.2, R76.1
unnamed: Q22.3, R75.1
unnamed: R64.2, U1.6
unnamed: K7.9, K7.14, T7.2
unnamed: P7.2, T7.1
unnamed: K7.11, K7.12, P7.1
unnamed: R80.1, T8.4
unnamed: R74.2, U1.7
unnamed: P8.2, T8.1
unnamed: Q24.3, R82.1
unnamed: K8.11, K8.12, P8.1
unnamed: Q24.1, U4.14
unnamed: K8.9, K8.14, T8.2
unnamed: D33.1, D34.2, R80.2, U4.13
unnamed: Q22.1, R73.2, R74.1
unnamed: D31.2, D32.1, K8.22, Q23.3
unnamed: D27.1, R67.2
unnamed: Q21.3, R72.1
unnamed: Q19.3, R65.1
unnamed: R70.1, T7.4
unnamed: C13.1, D29.2, D30.1, R68.2, R69.1, T7.3, U4.10
unnamed: D29.1, D30.2, R70.2, U4.9
unnamed: C14.1, R71.1, R72.2, U2.5
unnamed: K6.11, K6.12, P6.1
unnamed: D23.2, D24.1, K6.22, Q17.3
unnamed: C12.1, R61.1, R62.2, U2.4
unnamed: R54.2, U1.5
unnamed: K6.9, K6.14, T6.2
unnamed: Q19.1, R63.2, R64.1
unnamed: Q20.1, R65.2, R66.1
unnamed: Q21.1, U4.8
unnamed: D27.2, D28.1, K7.22, Q20.3
unnamed: J2.5, U1.9
unnamed: J2.7, U2.10
unnamed: D1.1, R1.2
unnamed: D2.1, R2.1
unnamed: R4.2, U1.15
unnamed: Q4.3, R15.1
unnamed: R14.2, U1.1
unnamed: K1.11, K1.12, P1.1
unnamed: D9.1, D10.2, R20.2, U3.6
unnamed: Q6.3, R22.1
unnamed: R20.1, T2.4
unnamed: D7.1, R17.2
unnamed: Q3.1, U3.1
unnamed: Q1.1, R3.2, R4.1
unnamed: D3.2, D4.1, K1.22, Q2.3
unnamed: D3.1, R7.2
unnamed: Q2.1, R5.2, R6.1
unnamed: Q1.3, R5.1
unnamed: P1.2, T1.1
unnamed: C4.1, R21.1, R22.2, U2.12
unnamed: D5.1, D6.2, R10.2, U3.2
unnamed: C1.1, D5.2, D6.1, R8.2, R9.1, T1.3, U3.3
unnamed: C2.1, R11.1, R12.2, U2.11
unnamed: Q3.3, R12.1
unnamed: R10.1, T1.4
unnamed: Q7.1, R23.2, R24.1
unnamed: D11.2, D12.1, K3.22, Q8.3
unnamed: C6.1, R31.1, R32.2, U2.13
unnamed: Q9.3, R32.1
unnamed: Q9.1, U3.8
unnamed: K3.11, K3.12, P3.1
unnamed: D11.1, R27.2
unnamed: Q8.1, R25.2, R26.1
unnamed: Q7.3, R25.1
unnamed: R30.1, T3.4
unnamed: C5.1, D13.2, D14.1, R28.2, R29.1, T3.3, U3.10
unnamed: Q10.3, R35.1
unnamed: C7.1, D17.2, D18.1, R38.2, R39.1, T4.3, U3.12
unnamed: D17.1, D18.2, R40.2, U3.13
unnamed: D15.1, R37.2
unnamed: R24.2, U1.2
unnamed: K3.9, K3.14, T3.2
unnamed: P3.2, T3.1
unnamed: Q6.1, U3.7
unnamed: D7.2, D8.1, K2.22, Q5.3
unnamed: K2.11, K2.12, P2.1
unnamed: Q4.1, R13.2, R14.1
unnamed: Q5.1, R15.2, R16.1
unnamed: C3.1, D9.2, D10.1, R18.2, R19.1, T2.3, U3.5
unnamed: D13.1, D14.2, R30.2, U3.9
unnamed: P2.2, T2.1
unnamed: K2.9, K2.14, T2.2
unnamed: K1.9, K1.14, T1.2
